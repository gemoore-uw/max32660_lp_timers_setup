# IAR project max32660_lp_timers_setup.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: ..; ..\RTE; $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c
  group CMSIS-Pack
    ../RTE/: RTE_Components.h
  group CMSIS-Pack/Peripherals RTC
    ${CMSIS_PACK_PATH_Maxim#MAX32660#1.4.0}$/Libraries/MAX32660PeriphDriver/Source/: rtc.c
  group CMSIS-Pack/Maxim MAX32660 EVKIT Board Support _BSP.Board Support_1.4.0
    ${CMSIS_PACK_PATH_Maxim#MAX32660#1.4.0}$/Boards/Maxim/MAX32660_EVKIT/Common/EvKit_V1/Source/: board.c
    ${CMSIS_PACK_PATH_Maxim#MAX32660#1.4.0}$/Boards/Maxim/MAX32660_EVKIT/Common/Source/: led.c pb.c stdio.c
  group CMSIS-Pack/Device Startup
    ../RTE/Device/MAX32660/: cmain.s low_level_init.c mxc_config.h startup_max32660.s system_max32660.c
    ${CMSIS_PACK_PATH_Maxim#MAX32660#1.4.0}$/Libraries/MAX32660PeriphDriver/Source/: flc.c icc.c lp.c mxc_assert.c mxc_delay.c mxc_lock.c mxc_pins.c mxc_sys.c nvic_table.c
  group CMSIS-Pack/Peripherals GPIO
    ${CMSIS_PACK_PATH_Maxim#MAX32660#1.4.0}$/Libraries/MAX32660PeriphDriver/Source/: gpio.c
  group CMSIS-Pack/Peripherals Timers
    ${CMSIS_PACK_PATH_Maxim#MAX32660#1.4.0}$/Libraries/MAX32660PeriphDriver/Source/: tmr.c tmr_utils.c
  group CMSIS-Pack/Communications UART
    ${CMSIS_PACK_PATH_Maxim#MAX32660#1.4.0}$/Libraries/MAX32660PeriphDriver/Source/: uart.c
  group CMSIS-Pack/Communications SPI
    ${CMSIS_PACK_PATH_Maxim#MAX32660#1.4.0}$/Libraries/MAX32660PeriphDriver/Source/: spi.c spi17y.c spimss.c
  group CMSIS-Pack/Communications I2C
    ${CMSIS_PACK_PATH_Maxim#MAX32660#1.4.0}$/Libraries/MAX32660PeriphDriver/Source/: i2c.c
